## Config.in
```kconfig
config BR2_PACKAGE_NINVADERS
	bool "ninvaders"
	select BR2_PACKAGE_NCURSES
	help
	  ninvaders game

	  https://sourceforge.net/projects/ninvaders
```
